# Keil uVision project hConfTest.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MDR1986BE91 Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: hConfTest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: .\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c system_1986BE9x.c startup_1986be9x.s
