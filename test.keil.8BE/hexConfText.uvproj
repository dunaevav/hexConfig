# Keil uVision project hexConfText.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC845 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: hexConfText +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: START_AD.A51 main.c
